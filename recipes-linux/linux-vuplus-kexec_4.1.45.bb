LINUX_VUPLUS_VER = "4.1.45"
require recipes-linux/linux-vuplus_${LINUX_VUPLUS_VER}.bb
require linux-vuplus-kexec.inc
