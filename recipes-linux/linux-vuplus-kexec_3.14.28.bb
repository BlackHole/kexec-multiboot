LINUX_VUPLUS_VER = "3.14.28"
require recipes-linux/linux-vuplus_${LINUX_VUPLUS_VER}.bb
require linux-vuplus-kexec.inc
