LINUX_VUPLUS_VER = "3.13.5"
require recipes-linux/linux-vuplus_${LINUX_VUPLUS_VER}.bb
require linux-vuplus-chkroot.inc
