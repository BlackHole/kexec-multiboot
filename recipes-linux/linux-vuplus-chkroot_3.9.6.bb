LINUX_VUPLUS_VER = "3.9.6"
require recipes-linux/linux-vuplus_${LINUX_VUPLUS_VER}.bb
require linux-vuplus-chkroot.inc
